# Keil uVision project Project.uvprojx, settings and files
target 15A_Protection_SysTickFix (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: N32G455RCL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: N32G455 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\..\Libraries\CMSIS\core;..\..\Libraries\CMSIS\device;..\..\Libraries\n32g45x_std_periph_driver\inc;..\Ethercat\Inc;..\Ethercat\port;..\Ethercat\src;..\SYSTEM\usart;..\SYSTEM\delay;..\SYSTEM\sys;..\USMART;..\User;..\RS485_ModbusRTU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3f000
  memory RVCT9: RAM 0x20000000 size 0x24000
  link misc: --diag_suppress=L6329
  group CMSIS
    ../User/: DriveSafety.c DriveParameters.c
    ../../Libraries/n32g45x_std_periph_driver/src/: n32g45x_iwdg.c
    ../../Libraries/CMSIS/device/: system_n32g45x.c
  group MDK-ARM
    ../../Libraries/CMSIS/device/startup/: startup_n32g45x.s
  group Application
    ../Ethercat/port/: el9800hw.c
    ../User/: main.c EthercatMotorControl.c Timer.c QSPI.c DriveTelemetry.c DriveCurrent.c DriveFault.c DriveBoot.c AdcInit.c PwmInit.c can.c eeprom.c eeprom_console.c IoIntInit.c rs485.c exti.c SciInit.c n32g45x_it.c flash.c u_i2c.c uartc.c PulseHandle.c Errorhadle.c SaveFunc.c N32G455.lib
  group RS485_ModbusRTU
    ../RS485_ModbusRTU/: modbus.c
  group Src
    ../Ethercat/src/: coeappl.c ecatappl.c cia402appl.c
  group Stack
    ../Ethercat/src/: ecatcoe.c ecatslv.c mailbox.c objdef.c sdoserv.c
  group N32G45x_StdPeriph_Driver
    ../../Libraries/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_can.c n32g45x_dac.c n32g45x_dma.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_pwr.c n32g45x_rcc.c n32g45x_spi.c n32g45x_tim.c n32g45x_usart.c n32g45x_qspi.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: systick.c
